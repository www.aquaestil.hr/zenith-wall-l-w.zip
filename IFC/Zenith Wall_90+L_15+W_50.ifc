Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-03-05T17:41:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 05 17:41:44 2021 * Host: zb500ssd * Database: C:\Users\BORIS~1.ZIV\AppData\Local\Temp\{8B95C177-CB55-44DC-B277-1EE53A879F4C}\ifc * Database version: 5507 * Database creation date: Fri Mar 05 17:41:43 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 05 17:41:43 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 05 17:41:43 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: WALL+L+W, Zenit Wall+L+W:WALL+L+W:205724
In: Level 1
Type - Material: Srebrni profil, Prozirno staklo
Type - Dimensions - A Ugradbena mjera sa profilima: 890 mm; B dubina +L: 300 mm; C dubina +W: 990 mm
Type - Identity Data - Boja profila: crna, srebrna; Izradio: Intelika d.o.o; Manufacturer: Aquaestil; Model: Zenith Wall + L + W; Type Name: WALL+L+W; Web adresa: https://www.aquaestil.hr/hr/proizvodi/paravani/391-zenith-wall-l-w.html
Type - Materials and Finishes - Material: Srebrni profil; Material glass: Prozirno staklo
Type - Other - Category: Generic Models; Family Name: Zenit Wall+L+W
Pset_BuildingElementProxyCommon - Reference: Zenit Wall+L+W:WALL+L+W
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Constraints - Dubina do 104 max: 500 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Sirina W max 1045: 500 mm; TIP Zenith +L: +L 15; TIP Zenith +W: 55; TIP Zenith Wall: STIJENA 90; VIDLJIVOST +W: yes
Dimensions - Area: 3.80529 m2; Dubina: 500 mm; Sirina +W: 500 mm; Visina H: 2000 mm; Volume: 0.0316335 m3
Other - Family: Zenit Wall+L+W: WALL+L+W; Family and Type: Zenit Wall+L+W: WALL+L+W; Type: Zenit Wall+L+W: WALL+L+W; Type Id: Zenit Wall+L+W: WALL+L+W
Phasing - Phase Created: New Construction
